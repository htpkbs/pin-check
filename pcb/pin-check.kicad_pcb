# Repository htpkbs/pin-check

File README.md:

**This is a work in progress for now!**

# Table of Contents

* [Overview](#overview)
* [DIY](#diy)
  * [PCB](#pcb)
  * [Components](#components)
  * [Bootloader](#bootloader)
  * [Acrylic Window](#acrylic-window)
* [Building the Kit](#building-the-kit)
* [Designing a Keyboard](#designing-a-keyboard)
* [QMK](#qmk)
* [Acknowledgments and Sublicenses](#acknowledgments-and-sublicenses)

# Overview
<a name="overview" />

The pin-check is a printed circuit board (PCB) for hand-wired keyboards that uses all through-hole components, and supports [QMK firmware](https://qmk.fm/), MX or Alps keyswitches, and split layouts. The keyswitch spacing is 19.05 mm and the USB connector is USB-C.

It is inspired by the [Plaid](https://github.com/hsgw/plaid), [Discipline](https://github.com/coseyfannitutti/discipline), and [Postage Board](https://github.com/LifeIsOnTheWire/Postage-Board/blob/master/README.md). It's called the pin-check because pin check is a smaller pattern than plaid and [Gingham](https://yiancar-designs.com/product/gingham/). It will stick up above your case or plate, both to show off the components 😎 and because through-hole components can't fit under the keyswitches on the back side of the PCB like the surface-mount device (SMD) components of something like Postage Board can.

It looks something like this (before any of the components are added).

[There is a PDF of the schematic here](assets/schematic.pdf).

Kits that include the PCB and all components (except for keyswitches) may be for sale at some point.

# DIY
<a name="diy" />

**If you purchased a kit you can [skip to building the kit](#building-the-kit)!**

## PCB
<a name="pcb" />

To get a PCB, you can submit the files in this repository to any PCB manufacturer. [OSH Park](https://oshpark.com/) lets you upload `.kicad_pcb` files directly, or you can generate Gerber and drill files and submit them to your preferred PCB manufacturer (the manufacturer should have instructions to do this using [KiCad](https://kicad-pcb.org/)).

## Components
<a name="components" />

All of the required electrical components and quantities are listed in the [bill of materials (BOM)](BOM.md). You can purchase these components (or equivalent components) from DigiKey, Mouser, or anywhere else you can find them. The BOM does not include parts like keyswitches or keycaps.

## Bootloader
<a name="bootloader" />

To flash new QMK keyboard layouts onto the keyboard (without using an AVR programmer or the ISP pins), the bootloader on the ATmega328P microcontroller unit (MCU) needs to support USB. [USBaspLoader](https://github.com/baerwolf/USBaspLoader) is a bootloader for AVR MCUs that uses [V-USB](https://www.obdev.at/products/vusb/index.html) for USB support.

TODO: Add instructions to use avrdude with either an AVR programmer or Raspberry Pi GPIO pins to flash the bootloader onto a fresh chip/MCU.

## Acrylic Window
<a name="acrylic-window" />

If you want to mount a clear acrylic window above the exposed portion of the PCB, you can upload the `assets/window.svg` file in this repository to your preferred laser cutting service or use it to cut a piece of clear acrylic yourself (something around 3mm thick should be good). To mount the window, you need four M2 female-female standoffs that are at least 10 mm long, and eight M2 screws to secure the standoffs to the window and the PCB.

# Building the Kit
<a name="building-the-kit" />

There may be instructions here for assembling the kit (soldering components onto the PCB) at some point. It should be fairly straightforward if you know how to solder. The hardest part to solder is the USB-C jack. It's helpful to apply some flux (with a flux pen) to the smaller pins, get some solder on your iron, and drag it across the pins. It's also helpful to use some sort of magnifier to make sure all of the pins are soldered correctly.

Once all components are soldered onto the PCB (and **before** soldering the PCB onto your keyswitches) you should connect it with USB and press the `RESET` button while holding down the `BOOT` button. This should boot the chip into the USBaspLoader bootloader, which should be recognized by [QMK Toolbox](https://qmk.fm/toolbox/) or avrdude. If it is not recognized, try the button combination again or check your solder joints.

# Designing a Keyboard
<a name="designing-a-keyboard" />

If you already have a plate, case, and keyswitches, and are familiar with hand-wiring, you can [skip to the QMK section](#qmk).

TODO: Add information about limitations of the number of I/O pins on the ATmega328P (and implications for layouts).

TODO: Add example instructions of designing and purchasing a plate (probably using [Keyboard Layout Editor](http://www.keyboard-layout-editor.com/), [swillkb](http://builder.swillkb.com/), and [OSH Cut](https://app.oshcut.com/) or another laser cutting service.

TODO: Add information about standoffs and screws for a sandwich-style case.

TODO: Add information about hand-wiring and required parts (more diodes!).

# QMK
<a name="qmk" />

TODO: Add instructions about creating a keymap in QMK and flashing it onto the keyboard. Mention that H11 and H12 are not available to use for rows or columns if you're setting up a split keyboard!

FYI: The pin-check board alone has 18 I/O pins. If you use the TRRS jack (for a split keyboard) or I2C headers (to attach another device), pins `C4` and `C5` are used for I2C and are unavailable for I/O.

# Acknowledgments and Sublicenses
<a name="acknowledgments-and-sublicenses" />

* Thank you to [coseyfannitutti](https://github.com/coseyfannitutti) who designed the [Discipline PCB](https://github.com/coseyfannitutti/discipline) for the footprints `D_DO-35_SOD27_P5.08mm_Horizontal.kicad_mod` and `USB_C_GCT_USB4085.kicad_mod`! [The Creative Commons license for these is included here](LICENSE.CFTKB).
* Thanks to [ai03-2725](https://github.com/ai03-2725) for the symbol `MX-NoLED` (which I slightly modified to swap the `ROW` and `COL` labels) and footprint `MX-1U-NoLED.kicad_mod` from the [MX_Alps_Hybrid repository](https://github.com/ai03-2725/MX_Alps_Hybrid). The footprint is also slightly modified (I added F.Mask to the technical layers of pads 1 and 2, so it would show up accurately in Pcbnew's 3D viewer) from the version in [dsanchezseco's pull request](https://github.com/ai03-2725/MX_Alps_Hybrid/pull/15). [The MIT license for these is included here](LICENSE.ai03).
* The symbol `SJ-43514` and footprint `CUI_SJ-43514.kicad_mod` are from [CUI Devices](https://www.cuidevices.com/product/resource/pcbfootprint/sj-43514) (with minor modifications to the footprint to move some weird edge cuts to the Cmts.User layer). These files are not licensed by CUI Devices and are free to use.
* Lastly, I have to shout out the [plaid PCB](https://github.com/hsgw/plaid) by [hsgw](https://github.com/hsgw) one more time, because it was my first through-hole kit, it inspired me to learn more about circuit and PCB design, and it has been a great resource to learn from since it's open source.

## KiCad design pcb/pin-check.kicad_pcb

Parts:
C1, C2: 22pF; C_Rect_L4.0mm_W2.5mm_P2.50mm
C3: 4.7u; C_Radial_D4.0mm_H7.0mm_P1.50mm
C4, C5: 0.1u; C_Rect_L4.0mm_W2.5mm_P2.50mm
D1, D2, D3, D4: 1N4148; D_DO-35_SOD27_P5.08mm_Horizontal
D7, D8: 3.6V; D_DO-35_SOD27_P5.08mm_Horizontal
F1: 100mA; Fuse_Littelfuse_395Series
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H15, H16, H17, H18: Pad; SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm
H19, H20, H21, H22: MountingHole; MountingHole_2.2mm_M2
J1: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J2: SJ-43514; CUI_SJ-43514
J3: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
P1: USB_C_Receptacle_USB2.0; USB_C_GCT_USB4085
R1: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R3: 5.1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R4: 1.5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5, R6: 75R; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R7, R8: 4.7k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
SW1, SW2, SW3, SW4: MX-NoLED; MX-1U-NoLED
SW7: Reset; SW_PUSH_6mm_H4.3mm
SW8: Boot; SW_PUSH_6mm_H4.3mm
U1: ATmega328P-PU; DIP-28_W7.62mm
Y1: 16MHz; Crystal_HC49-4H_Vertical

Connections:
+5V: C3.2, C4.2, C5.2, F1.1, J1.2 (VCC), J2.4, J3.1, R1.1, R4.1, R7.1, R8.1, U1.7 (VCC), U1.20 (AVCC)
/B1: H18.1, U1.15 (PB1)
/B2: H17.1, U1.16 (PB2)
/B3: H16.1, J1.4 (MOSI), U1.17 (PB3)
/B4: H15.1, J1.1 (MISO), U1.18 (PB4)
/C3: H14.1, U1.26 (PC3)
/ColA: H2.1, J1.3 (SCK), SW1.2 (ROW), U1.19 (PB5)
/ColB: H3.1, SW2.2 (ROW), U1.23 (PC0)
/ColC: H4.1, SW3.2 (ROW), U1.24 (PC1)
/ColD: H5.1, SW4.2 (ROW), U1.25 (PC2)
/D0: H6.1, U1.2 (PD0)
/D1: H7.1, U1.3 (PD1)
/D4: H8.1, U1.6 (PD4)
/D5: H9.1, SW8.1, U1.11 (PD5)
/D6: H10.1, U1.12 (PD6)
/D7: H11.1, U1.13 (PD7)
/D+: R6.2, U1.4 (PD2)
/D-: R5.1, U1.5 (PD3)
/Reset: J1.5 (~RST), R1.2, SW7.1, U1.1 (~RESET~/PC6)
/Row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), H1.1, U1.14 (PB0)
/SCL: H12.1, J2.2, J3.4, R7.2, U1.28 (PC5)
/SDA: H13.1, J2.3, J3.2, R8.2, U1.27 (PC4)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, D7.2 (A), D8.2 (A), J1.6 (GND), J2.1, J3.3, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), R2.2, R3.2, SW7.2, SW8.2, U1.8 (GND), U1.22 (GND)
unnamed: C1.2, U1.9 (XTAL1/PB6), Y1.2
unnamed: C2.2, U1.10 (XTAL2/PB7), Y1.1
unnamed: D1.2 (A), SW1.1 (COL)
unnamed: D2.2 (A), SW2.1 (COL)
unnamed: D3.2 (A), SW3.1 (COL)
unnamed: D4.2 (A), SW4.1 (COL)
unnamed: D7.1 (K), P1.A7 (D-), P1.B7 (D-), R4.2, R5.2
unnamed: D8.1 (K), P1.A6 (D+), P1.B6 (D+), R6.1
unnamed: F1.2, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS)
unnamed: P1.A5 (CC1), R3.1
unnamed: P1.B5 (CC2), R2.1

Notes on the sheet:
USB Port
Solder Holes For Additional Rows and Columns
Boot and Reset Switches
Microcontroller, Crystal, and ISP Headers
Decoupling Capacitors
Mounting Holes
TRRS Jack
Keyswitches and Diodes
I2C/TWI Solder Holes

Board: 2 copper layers, 76.2 x 53.3 mm, 54 parts (19 on the bottom side), 34 nets.

File BOM.md:

# Bill of Materials (BOM)

SW1-SW6 (keyswitches), H1-H17 (just empty solder holes on the PCB), and H18-H21 (window mounting holes) are not included.

| Photo | Reference | Quantity | Value | Manufacturer | Manufacturer Part No. | DigiKey Link |
| --- | --- | --- | --- | --- | --- | --- |
| ![C1, C2](assets/photos/C1-C2.jpg) | C1, C2 | 2 | 22pF | Vishay BC Components | K220J15C0GH53L2 | https://www.digikey.com/product-detail/en/vishay-bc-componen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 |
| ![C3](assets/photos/C3.jpg) | C3 | 1 | 4.7u | Panasonic Electronic Components | ECE-A1HKA4R7 | https://www.digikey.com/product-detail/en/panasonic-electron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 |
| ![C4, C5](assets/photos/C4-C5.jpg) | C4, C5 | 2 | 0.1u | Vishay BC Components | K104Z15Y5VF5TL2 | https://www.digikey.com/product-detail/en/vishay-bc-componen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 |
| ![D1-D4](assets/photos/D1-D4.jpg) | D1-D4 | 4 | 1N4148 | Vishay Semiconductor Diodes Division | TZX3V6B-TR | https://www.digikey.com/product-detail/en/vishay-semiconduct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 |
| ![D7, D8](assets/photos/D7-D8.jpg) | D7, D8 | 2 | 3.6V | Vishay Semiconductor Diodes Division | 1N4148TR | https://www.digikey.com/product-detail/en/vishay-semiconduct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 |
| ![F1](assets/photos/F1.jpg) | F1 | 1 | 100mA | Bourns Inc. | MF-R010 |https://www.digikey.com/product-detail/en/bourns-inc/MF-R010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 |
| ![J1](assets/photos/J1.jpg) | J1 | 1 | AVR-ISP-6 | METZ CONNECT USA Inc. | PR20203VBDN | https://www.digikey.com/product-detail/en/metz-connect-usa-i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 |
| ![J2](assets/photos/J2.jpg) | J2 | 1 | SJ-43514 | CUI Devices | SJ-43514 | https://www.digikey.com/product-detail/en/cui-inc/SJ-43514/C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 |
| ![P1](assets/photos/P1.jpg) | P1 | 1 | USB_C_Receptacle_USB2.0 | GCT | USB4085-GF-A | https://www.digikey.com/product-detail/en/USB4085-GF-A/2073-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 |
| ![R1](assets/photos/R1.jpg) | R1 | 1 | 10k | Vishay BC Components | SFR16S0001002JA500 | https://www.digikey.com/product-detail/en/vishay-bc-componen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 |
| ![R2, R3](assets/photos/R2-R3.jpg) | R2, R3 | 2 | 5.1k | Vishay BC Components | MBA02040C5101FCT00 | https://www.digikey.com/product-detail/en/vishay-bc-componen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 |
| ![R4](assets/photos/R4.jpg) | R4 | 1 | 1.5k | Vishay BC Components | SFR16S0001501JA500 | https://www.digikey.com/product-detail/en/vishay-bc-componen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 |
| ![R5, R6](assets/photos/R5-R6.jpg) | R5, R6 | 2 | 75R | Vishay BC Components | SFR16S0007509FR500 | https://www.digikey.com/product-detail/en/vishay-bc-componen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 |
| ![R7, R8](assets/photos/R7-R8.jpg) | R7, R8 | 2 | 4.7k | Vishay BC Components | MBA02040C5101FCT00 | https://www.digikey.com/product-detail/en/vishay-bc-componen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 |
| ![SW7](assets/photos/SW7.jpg) | SW7 | 1 | Reset | TE Connectivity ALCOSWITCH Switches | 1825910-3 | https://www.digikey.com/product-detail/en/te-connectivity-al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 |
| ![SW8](assets/photos/SW8.jpg) | SW8 | 1 | Boot | TE Connectivity ALCOSWITCH Switches | 1825910-2 | https://www.digikey.com/product-detail/en/te-connectivity-al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 |
| ![U1](assets/photos/U1.jpg) | U1 | 1 | ATmega328P-PU | Microchip Technology | ATMEGA328P-PU | https://www.digikey.com/product-detail/en/microchip-technolo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 |
| ![U1 socket](assets/photos/U1-socket.jpg) | U1 (socket) | 1 | DIP Socket | Mill-Max Manufacturing Corp. | 115-43-328-41-001000 | https://www.digikey.com/product-detail/en/mill-max-manufactu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 |
| ![Y1](assets/photos/Y1.jpg) | Y1 | 1 | 16MHz | Abracon LLC | ABL-16.000MHZ-B2 | https://www.digikey.com/product-detail/en/abracon-llc/ABL-16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 |

## KiCad design pcb-expansion/pin-check-expansion.kicad_pcb

Board: 2 copper layers, 38.1 x 53.3 mm, 24 parts (13 on the bottom side), 9 nets, no tracks yet.

Parts:
D1, D2: 1N4148; D_DO-35_SOD27_P5.08mm_Horizontal
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13: MountingHole_Pad; SolderWire-0.5sqmm_1x01_D0.9mm_OD2.1mm
H14, H15, H16, H17: MountingHole_Pad; MountingHole_2.2mm_M2
H18: MountingHole_Pad; SolderWire-0.25sqmm_1x01_D0.65mm_OD2mm
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
SW1, SW2: MX-NoLED; MX-1U-NoLED
U1: MCP23017_SP; DIP-28_W7.62mm

Connections:
+5V: H13.1, J1.4, U1.9, U1.18
/ColE: H2.1, SW1.2, U1.21
/ColF: H3.1, SW2.2, U1.22
/Row0: D1.1, D2.1, H1.1
/SCL: H10.1, J1.1, U1.12
/SDA: H12.1, J1.3, U1.13
GND: H11.1, J1.2, U1.10, U1.15, U1.16, U1.17
unnamed: D1.2, SW1.1
unnamed: D2.2, SW2.1

## KiCad design pcb/pcb_attempts/second-pin-check.kicad_pcb

Board: 2 copper layers, 114.5 x 43.1 mm, 39 parts (2 on the bottom side), 30 nets.

Parts:
C1, C2: 22pF; C_Radial_D6.3mm_H5.0mm_P2.50mm
D1, D2, D3, D4, D5, D6: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D7, D8: 3.6V; D_DO-35_SOD27_P7.62mm_Horizontal
F1: 100mA; Fuse_Bourns_MF-RG300
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11: Pad; PinSocket_1x01_P2.00mm_Vertical
P1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4085
R1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3: 5.1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 1.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6: 75R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push; SW_Cherry_MX_1.00u_PCB
SW7: Reset; SW_PUSH_6mm_H4.3mm
SW8: Boot; SW_PUSH_6mm_H4.3mm
U1: ATmega328P-PU; DIP-28_W7.62mm
Y1: 16MHz; Crystal_HC49-4H_Vertical

Connections:
+5V: F1.1, R1.1, R4.1, U1.7, U1.20
/Boot: SW8.1, U1.11
/Col0: H6.1, SW1.1, U1.19
/Col1: H7.1, SW2.1, U1.23
/Col2: H8.1, SW3.1, U1.24
/Col3: H9.1, SW4.1, U1.25
/Col4: H10.1, SW5.1, U1.26
/Col5: H11.1, SW6.1, U1.27
/D+: R6.2, U1.4
/D-: R5.1, U1.5
/Reset: R1.2, SW7.1, U1.1
/Row0: D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, H1.1, U1.14
/Row1: H2.1, U1.15
/Row2: H3.1, U1.16
/Row3: H4.1, U1.17
/Row4: H5.1, U1.18
GND: C1.1, C2.1, D7.2, D8.2, P1.A1, P1.A12, P1.B1, P1.B12, P1.S1, R2.2, R3.2, SW7.2, SW8.2, U1.8, U1.22
unnamed: C1.2, U1.9, Y1.2
unnamed: C2.2, U1.10, Y1.1
unnamed: D1.2, SW1.2
unnamed: D2.2, SW2.2
unnamed: D3.2, SW3.2
unnamed: D4.2, SW4.2
unnamed: D5.2, SW5.2
unnamed: D6.2, SW6.2
unnamed: D7.1, P1.A7, P1.B7, R4.2, R5.2
unnamed: D8.1, P1.A6, P1.B6, R6.1
unnamed: F1.2, P1.A4, P1.A9, P1.B4, P1.B9
unnamed: P1.A5, R3.1
unnamed: P1.B5, R2.1

## Commit log

2020-07-17 still a wip, uploading bom
2020-07-17 readme
2020-07-17 aspiration!
2020-07-17 fix table
2020-07-17 6 diodes
2020-07-17 aspirational README
2020-07-17 name
2020-07-17 leds
2020-07-17 image
2020-07-18 add license text to readme
2020-07-18 remove images
2020-07-18 remove
2020-07-18 Create LICENSE
2020-07-18 Update LICENSE
2020-07-19 a bunch of changes, update bom, new render
2020-07-19 add back
2020-07-19 update images and move usb port down
2020-07-19 update renders
2020-07-19 new renders and something else?
2020-07-19 typo
2020-07-19 schematic pdf
2020-07-19 remove bak files
2020-07-20 smaller!
2020-07-21 I forget
2020-07-21 something
2020-07-21 back silk
2020-07-21 move c3
2020-07-21 update bom
2020-07-23 symbols for trrs
2020-07-25 new version
2020-07-27 gerber and new images
2020-07-27 add j2
2020-07-27 part for isp header
2020-07-30 v1.0.1
2020-07-30 include mcu socket in bom
2020-07-30 window svg
2020-07-30 ignore gerber
2020-08-01 Update README, add hybrid MX/ALPS switch footprints
2020-08-01 Re-add gerber ignore
2020-08-01 full toc
2020-08-01 skip links
2020-08-01 assets dir, more ignores
2020-08-01 Ignore more things
2020-08-01 window path
2020-08-01 Details on modifications
2020-08-01 Rename some files
2020-08-01 update bom again
2020-08-01 split note
2020-08-01 new png
2020-08-01 update some traces
2020-08-01 mention MX/Alps
2020-08-01 don't mention SW
2020-08-01 license
2020-08-01 change a track
2020-08-01 stray tracks
2020-08-01 some changes
2020-08-02 probably not
2020-08-02 also probably not
2020-08-03 asdf
2020-08-05 resolve some issues and update images
2020-08-05 move everything down
2020-08-05 add expansion
2020-08-05 pre-breakout board expirement commit
2020-08-05 update README with some common layouts
2020-08-05 buttons on top
2020-08-06 6x20
2020-08-06 renamed things
2020-08-06 v2.0.0?
2020-08-06 something on pcb
2020-08-06 last save
2020-08-06 mention 6x12
2020-08-18 start updating expansion board to use mcp23017
2020-09-08 photos
2020-09-08 udpate bom
2020-09-08 casing
2020-09-10 add bootloader note
2021-01-17 update license url

Notices in the files:
pcb/pin-check.kicad_pcb:
License: BSD 2-Clause
